# Repository eSpark-Backup/stephenlong-ledpcbs (continued)

## EAGLE design docs/Client-Files/Design-Files (2x2)/RU-PCBA-2X2-001-03.brd (continued)

Schematic: RU-PCBA-2X2-001-03.sch, sheet 9, Row 9

Parts:
C195, C196, C197, C198, C199, C200, C201, C202, C203, C204, C205, C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217, C218: C-EUC1206; C1206; MPN C_104
LD583, LD589, LD595, LD601, LD607, LD613, LD619, LD625, LD631, LD637, LD643, LD649: R; 5050LED; MPN R_5050
LD584, LD590, LD596, LD602, LD608, LD614, LD620, LD626, LD632, LD638, LD644, LD650: G; 5050LED; MPN G_5050
LD585, LD591, LD597, LD603, LD609, LD615, LD621, LD627, LD633, LD639, LD645, LD651: B; 5050LED; MPN B_5050
LD586, LD592, LD598, LD604, LD610, LD616, LD622, LD628, LD634, LD640, LD646, LD652: A; 5050LED; MPN A_5050
LD587, LD593, LD599, LD605, LD611, LD617, LD623, LD629, LD635, LD641, LD647, LD653: C; 5050LED; MPN C_5050
LD588, LD594, LD600, LD606, LD612, LD618, LD624, LD630, LD636, LD642, LD648, LD654: L; 5050LED; MPN L_5050
R971, R976, R981, R986, R991, R996, R1001, R1006, R1011, R1016, R1021, R1026, R1031, R1036, R1041, R1046, R1051, R1056, R1061, R1066, R1071, R1076, R1081, R1086: 2k; R1206; MPN R_VDD
R972, R973, R977, R978, R982, R983, R987, R988, R992, R993, R997, R998, R1002, R1003, R1007, R1008, R1012, R1013, R1017, R1018, R1022, R1023, R1027, R1028, R1032, R1033, R1037, R1038, R1042, R1043, R1047, R1048, R1052, R1053, R1057, R1058, R1062, R1063, R1067, R1068, R1072, R1073, R1077, R1078, R1082, R1083, R1087, R1088: 500; R0805; MPN R_500
R974, R979, R984, R989, R994, R999, R1004, R1009, R1014, R1019, R1024, R1029, R1034, R1039, R1044, R1049, R1054, R1059, R1064, R1069, R1074, R1079, R1084, R1089: 120; R0805; MPN R_120
R975, R980, R985, R990, R995, R1000, R1005, R1010, R1015, R1020, R1025, R1030, R1035, R1040, R1045, R1050, R1055, R1060, R1065, R1070, R1075, R1080, R1085, R1090: 4.3K; R0805; MPN R_EXT
U193, U194, U195, U196, U197, U198, U199, U200, U201, U202, U203, U204, U205, U206, U207, U208, U209, U210, U211, U212, U213, U214, U215, U216: UCS7604; SOP100P600X175-10N; MPN UCS7604

Connections:
+24V: LD583.A, LD584.A, LD585.A, LD586.A, LD587.A, LD588.A, LD589.A, LD590.A, LD591.A, LD592.A, LD593.A, LD594.A, LD595.A, LD596.A, LD597.A, LD598.A, LD599.A, LD600.A, LD601.A, LD602.A, LD603.A, LD604.A, LD605.A, LD606.A, LD607.A, LD608.A, LD609.A, LD610.A, LD611.A, LD612.A, LD613.A, LD614.A, LD615.A, LD616.A, LD617.A, LD618.A, LD619.A, LD620.A, LD621.A, LD622.A, LD623.A, LD624.A, LD625.A, LD626.A, LD627.A, LD628.A, LD629.A, LD630.A, LD631.A, LD632.A, LD633.A, LD634.A, LD635.A, LD636.A, LD637.A, LD638.A, LD639.A, LD640.A, LD641.A, LD642.A, LD643.A, LD644.A, LD645.A, LD646.A, LD647.A, LD648.A, LD649.A, LD650.A, LD651.A, LD652.A, LD653.A, LD654.A, R971.2, R976.2, R981.2, R986.2, R991.2, R996.2, R1001.2, R1006.2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; also elsewhere on the board
DOUT_U191: R973.2; also elsewhere on the board
DOUT_U192: R972.2, R978.2; also elsewhere on the board
DOUT_U197: R994.1, R997.2, R1003.2
DOUT_U198: R999.1, R1002.2, R1008.2
DOUT_U203: R1024.1, R1027.2, R1033.2
DOUT_U204: R1029.1, R1032.2, R1038.2
DOUT_U209: R1054.1, R1057.2, R1063.2
DOUT_U210: R1059.1, R1062.2, R1068.2
DOUT_U215: R1084.1, R1087.2; also elsewhere on the board
DOUT_U216: R1089.1; also elsewhere on the board
GND: C195.2, C196.2, C197.2, C198.2, C199.2, C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, R975.1, R980.1, R985.1, R990.1, R995.1, R1000.1, R1005.1, R1010.1, R1015.1, R1020.1, R1025.1, R1030.1, R1035.1, R1040.1, R1045.1, R1050.1, R1055.1, R1060.1, R1065.1, R1070.1, R1075.1, R1080.1, R1085.1, R1090.1, U193.5 (GND), U194.5 (GND), U195.5 (GND), U196.5 (GND), U197.5 (GND), U198.5 (GND), U199.5 (GND), U200.5 (GND), U201.5 (GND), U202.5 (GND), U203.5 (GND), U204.5 (GND), U205.5 (GND), U206.5 (GND), U207.5 (GND), U208.5 (GND), U209.5 (GND), U210.5 (GND), U211.5 (GND), U212.5 (GND), U213.5 (GND), U214.5 (GND), U215.5 (GND), U216.5 (GND); also elsewhere on the board
unnamed: C195.1, R971.1, U193.9 (VDD)
unnamed: LD583.K (C), U193.1 (R)
unnamed: LD584.K (C), U193.2 (G)
unnamed: LD585.K (C), U193.3 (B)
unnamed: R972.1, U193.8 (DIN)
unnamed: R973.1, U193.6 (FDIN)
unnamed: R974.2, U193.10 (DOUT)
unnamed: R975.2, U193.7 (REXT)
unnamed: LD586.K (C), U194.1 (R)
unnamed: LD587.K (C), U194.2 (G)
unnamed: LD588.K (C), U194.3 (B)
unnamed: C196.1, R976.1, U194.9 (VDD)
unnamed: R977.1, U194.8 (DIN)
unnamed: R978.1, U194.6 (FDIN)
unnamed: R979.2, U194.10 (DOUT)
unnamed: R980.2, U194.7 (REXT)
unnamed: R979.1, R982.2, R988.2
unnamed: C197.1, R981.1, U195.9 (VDD)
unnamed: LD589.K (C), U195.1 (R)
unnamed: LD590.K (C), U195.2 (G)
unnamed: LD591.K (C), U195.3 (B)
unnamed: R982.1, U195.8 (DIN)
unnamed: R983.1, U195.6 (FDIN)
unnamed: R984.2, U195.10 (DOUT)
unnamed: R985.2, U195.7 (REXT)
unnamed: LD592.K (C), U196.1 (R)
unnamed: LD593.K (C), U196.2 (G)
unnamed: LD594.K (C), U196.3 (B)
unnamed: C198.1, R986.1, U196.9 (VDD)
unnamed: R987.1, U196.8 (DIN)
unnamed: R988.1, U196.6 (FDIN)
unnamed: R974.1, R977.2, R983.2
unnamed: R989.2, U196.10 (DOUT)
unnamed: R990.2, U196.7 (REXT)
unnamed: R989.1, R992.2, R998.2
unnamed: C199.1, R991.1, U197.9 (VDD)
unnamed: LD595.K (C), U197.1 (R)
unnamed: LD596.K (C), U197.2 (G)
unnamed: LD597.K (C), U197.3 (B)
unnamed: R992.1, U197.8 (DIN)
unnamed: R993.1, U197.6 (FDIN)
unnamed: R994.2, U197.10 (DOUT)
unnamed: R995.2, U197.7 (REXT)
unnamed: LD598.K (C), U198.1 (R)
unnamed: LD599.K (C), U198.2 (G)
unnamed: LD600.K (C), U198.3 (B)
unnamed: C200.1, R996.1, U198.9 (VDD)
unnamed: R997.1, U198.8 (DIN)
unnamed: R998.1, U198.6 (FDIN)
unnamed: R984.1, R987.2, R993.2
unnamed: R999.2, U198.10 (DOUT)
unnamed: R1000.2, U198.7 (REXT)
unnamed: C201.1, R1001.1, U199.9 (VDD)
unnamed: LD601.K (C), U199.1 (R)
unnamed: LD602.K (C), U199.2 (G)
unnamed: LD603.K (C), U199.3 (B)
unnamed: R1002.1, U199.8 (DIN)
unnamed: R1003.1, U199.6 (FDIN)
unnamed: R1004.2, U199.10 (DOUT)
unnamed: R1005.2, U199.7 (REXT)
unnamed: LD604.K (C), U200.1 (R)
unnamed: LD605.K (C), U200.2 (G)
unnamed: LD606.K (C), U200.3 (B)
unnamed: C202.1, R1006.1, U200.9 (VDD)
unnamed: R1007.1, U200.8 (DIN)
unnamed: R1008.1, U200.6 (FDIN)
unnamed: R1009.2, U200.10 (DOUT)
unnamed: R1010.2, U200.7 (REXT)
unnamed: R1009.1, R1012.2, R1018.2
unnamed: C203.1, R1011.1, U201.9 (VDD)
unnamed: LD607.K (C), U201.1 (R)
unnamed: LD608.K (C), U201.2 (G)
unnamed: LD609.K (C), U201.3 (B)
unnamed: R1012.1, U201.8 (DIN)
unnamed: R1013.1, U201.6 (FDIN)
unnamed: R1014.2, U201.10 (DOUT)
unnamed: R1015.2, U201.7 (REXT)
unnamed: LD610.K (C), U202.1 (R)
unnamed: LD611.K (C), U202.2 (G)
unnamed: LD612.K (C), U202.3 (B)
unnamed: C204.1, R1016.1, U202.9 (VDD)
unnamed: R1017.1, U202.8 (DIN)
unnamed: R1018.1, U202.6 (FDIN)
unnamed: R1004.1, R1007.2, R1013.2
unnamed: R1019.2, U202.10 (DOUT)
unnamed: R1020.2, U202.7 (REXT)
unnamed: R1019.1, R1022.2, R1028.2
unnamed: C205.1, R1021.1, U203.9 (VDD)
unnamed: LD613.K (C), U203.1 (R)
unnamed: LD614.K (C), U203.2 (G)
unnamed: LD615.K (C), U203.3 (B)
unnamed: R1022.1, U203.8 (DIN)
unnamed: R1023.1, U203.6 (FDIN)
unnamed: R1024.2, U203.10 (DOUT)
unnamed: R1025.2, U203.7 (REXT)
unnamed: LD616.K (C), U204.1 (R)
unnamed: LD617.K (C), U204.2 (G)
unnamed: LD618.K (C), U204.3 (B)
unnamed: C206.1, R1026.1, U204.9 (VDD)
unnamed: R1027.1, U204.8 (DIN)
unnamed: R1028.1, U204.6 (FDIN)
unnamed: R1014.1, R1017.2, R1023.2
unnamed: R1029.2, U204.10 (DOUT)
unnamed: R1030.2, U204.7 (REXT)
unnamed: C207.1, R1031.1, U205.9 (VDD)
unnamed: LD619.K (C), U205.1 (R)
unnamed: LD620.K (C), U205.2 (G)
unnamed: LD621.K (C), U205.3 (B)
unnamed: R1032.1, U205.8 (DIN)
unnamed: R1033.1, U205.6 (FDIN)
unnamed: R1034.2, U205.10 (DOUT)
unnamed: R1035.2, U205.7 (REXT)
unnamed: LD622.K (C), U206.1 (R)
unnamed: LD623.K (C), U206.2 (G)
unnamed: LD624.K (C), U206.3 (B)
unnamed: C208.1, R1036.1, U206.9 (VDD)
unnamed: R1037.1, U206.8 (DIN)
unnamed: R1038.1, U206.6 (FDIN)
unnamed: R1039.2, U206.10 (DOUT)
unnamed: R1040.2, U206.7 (REXT)
unnamed: R1039.1, R1042.2, R1048.2
unnamed: C209.1, R1041.1, U207.9 (VDD)
unnamed: LD625.K (C), U207.1 (R)
unnamed: LD626.K (C), U207.2 (G)
unnamed: LD627.K (C), U207.3 (B)
unnamed: R1042.1, U207.8 (DIN)
unnamed: R1043.1, U207.6 (FDIN)
unnamed: R1044.2, U207.10 (DOUT)
unnamed: R1045.2, U207.7 (REXT)
unnamed: LD628.K (C), U208.1 (R)
unnamed: LD629.K (C), U208.2 (G)
unnamed: LD630.K (C), U208.3 (B)
unnamed: C210.1, R1046.1, U208.9 (VDD)
unnamed: R1047.1, U208.8 (DIN)
unnamed: R1044.1, R1047.2, R1053.2
unnamed: R1048.1, U208.6 (FDIN)
unnamed: R1034.1, R1037.2, R1043.2
unnamed: R1049.2, U208.10 (DOUT)
unnamed: R1050.2, U208.7 (REXT)
unnamed: R1049.1, R1052.2, R1058.2
unnamed: C211.1, R1051.1, U209.9 (VDD)
unnamed: LD631.K (C), U209.1 (R)
unnamed: LD632.K (C), U209.2 (G)
unnamed: LD633.K (C), U209.3 (B)
unnamed: R1052.1, U209.8 (DIN)
unnamed: R1053.1, U209.6 (FDIN)
unnamed: R1054.2, U209.10 (DOUT)
unnamed: R1055.2, U209.7 (REXT)
unnamed: LD634.K (C), U210.1 (R)
unnamed: LD635.K (C), U210.2 (G)
unnamed: LD636.K (C), U210.3 (B)
unnamed: C212.1, R1056.1, U210.9 (VDD)
unnamed: R1057.1, U210.8 (DIN)
unnamed: R1058.1, U210.6 (FDIN)
unnamed: R1059.2, U210.10 (DOUT)
unnamed: R1060.2, U210.7 (REXT)
unnamed: C213.1, R1061.1, U211.9 (VDD)
unnamed: LD637.K (C), U211.1 (R)
unnamed: LD638.K (C), U211.2 (G)
unnamed: LD639.K (C), U211.3 (B)
unnamed: R1062.1, U211.8 (DIN)
unnamed: R1063.1, U211.6 (FDIN)
unnamed: R1064.2, U211.10 (DOUT)
unnamed: R1065.2, U211.7 (REXT)
unnamed: LD640.K (C), U212.1 (R)
unnamed: LD641.K (C), U212.2 (G)
unnamed: LD642.K (C), U212.3 (B)
unnamed: C214.1, R1066.1, U212.9 (VDD)
unnamed: R1067.1, U212.8 (DIN)
unnamed: R1068.1, U212.6 (FDIN)
unnamed: R1069.2, U212.10 (DOUT)
unnamed: R1070.2, U212.7 (REXT)
unnamed: R1069.1, R1072.2, R1078.2
unnamed: C215.1, R1071.1, U213.9 (VDD)
unnamed: LD643.K (C), U213.1 (R)
unnamed: LD644.K (C), U213.2 (G)
unnamed: LD645.K (C), U213.3 (B)
unnamed: R1072.1, U213.8 (DIN)
unnamed: R1073.1, U213.6 (FDIN)
unnamed: R1074.2, U213.10 (DOUT)
unnamed: R1075.2, U213.7 (REXT)
unnamed: LD646.K (C), U214.1 (R)
unnamed: LD647.K (C), U214.2 (G)
unnamed: LD648.K (C), U214.3 (B)
unnamed: C216.1, R1076.1, U214.9 (VDD)
unnamed: R1077.1, U214.8 (DIN)
unnamed: R1078.1, U214.6 (FDIN)
unnamed: R1064.1, R1067.2, R1073.2
unnamed: R1079.2, U214.10 (DOUT)
unnamed: R1080.2, U214.7 (REXT)
unnamed: R1079.1, R1082.2, R1088.2
unnamed: C217.1, R1081.1, U215.9 (VDD)
unnamed: LD649.K (C), U215.1 (R)
unnamed: LD650.K (C), U215.2 (G)
unnamed: LD651.K (C), U215.3 (B)
unnamed: R1082.1, U215.8 (DIN)
unnamed: R1083.1, U215.6 (FDIN)
unnamed: R1084.2, U215.10 (DOUT)
unnamed: R1085.2, U215.7 (REXT)
unnamed: LD652.K (C), U216.1 (R)
unnamed: LD653.K (C), U216.2 (G)
unnamed: LD654.K (C), U216.3 (B)
unnamed: C218.1, R1086.1, U216.9 (VDD)
unnamed: R1087.1, U216.8 (DIN)
unnamed: R1088.1, U216.6 (FDIN)
unnamed: R1074.1, R1077.2, R1083.2
unnamed: R1089.2, U216.10 (DOUT)
unnamed: R1090.2, U216.7 (REXT)

Schematic: RU-PCBA-2X2-001-03.sch, sheet 10, Row 10

Parts:
C219, C220, C221, C222, C223, C224, C225, C226, C227, C228, C229, C230, C231, C232, C233, C234, C235, C236, C237, C238, C239, C240, C241, C242: C-EUC1206; C1206; MPN C_104
LD655, LD661, LD667, LD673, LD679, LD685, LD691, LD697, LD703, LD709, LD715, LD721: R; 5050LED; MPN R_5050
LD656, LD662, LD668, LD674, LD680, LD686, LD692, LD698, LD704, LD710, LD716, LD722: G; 5050LED; MPN G_5050
LD657, LD663, LD669, LD675, LD681, LD687, LD693, LD699, LD705, LD711, LD717, LD723: B; 5050LED; MPN B_5050
LD658, LD664, LD670, LD676, LD682, LD688, LD694, LD700, LD706, LD712, LD718, LD724: A; 5050LED; MPN A_5050
LD659, LD665, LD671, LD677, LD683, LD689, LD695, LD701, LD707, LD713, LD719, LD725: C; 5050LED; MPN C_5050
LD660, LD666, LD672, LD678, LD684, LD690, LD696, LD702, LD708, LD714, LD720, LD726: L; 5050LED; MPN L_5050
R1091, R1096, R1101, R1106, R1111, R1116, R1121, R1126, R1131, R1136, R1141, R1146, R1151, R1156, R1161, R1166, R1171, R1176, R1181, R1186, R1191, R1196, R1201, R1206: 2k; R1206; MPN R_VDD
R1092, R1093, R1097, R1098, R1102, R1103, R1107, R1108, R1112, R1113, R1117, R1118, R1122, R1123, R1127, R1128, R1132, R1133, R1137, R1138, R1142, R1143, R1147, R1148, R1152, R1153, R1157, R1158, R1162, R1163, R1167, R1168, R1172, R1173, R1177, R1178, R1182, R1183, R1187, R1188, R1192, R1193, R1197, R1198, R1202, R1203, R1207, R1208: 500; R0805; MPN R_500
R1094, R1099, R1104, R1109, R1114, R1119, R1124, R1129, R1134, R1139, R1144, R1149, R1154, R1159, R1164, R1169, R1174, R1179, R1184, R1189, R1194, R1199, R1204, R1209: 120; R0805; MPN R_120
R1095, R1100, R1105, R1110, R1115, R1120, R1125, R1130, R1135, R1140, R1145, R1150, R1155, R1160, R1165, R1170, R1175, R1180, R1185, R1190, R1195, R1200, R1205, R1210: 4.3K; R0805; MPN R_EXT
U217, U218, U219, U220, U221, U222, U223, U224, U225, U226, U227, U228, U229, U230, U231, U232, U233, U234, U235, U236, U237, U238, U239, U240: UCS7604; SOP100P600X175-10N; MPN UCS7604

Connections:
+24V: LD655.A, LD656.A, LD657.A, LD658.A, LD659.A, LD660.A, LD661.A, LD662.A, LD663.A, LD664.A, LD665.A, LD666.A, LD667.A, LD668.A, LD669.A, LD670.A, LD671.A, LD672.A, LD673.A, LD674.A, LD675.A, LD676.A, LD677.A, LD678.A, LD679.A, LD680.A, LD681.A, LD682.A, LD683.A, LD684.A, LD685.A, LD686.A, LD687.A, LD688.A, LD689.A, LD690.A, LD691.A, LD692.A, LD693.A, LD694.A, LD695.A, LD696.A, LD697.A, LD698.A, LD699.A, LD700.A, LD701.A, LD702.A, LD703.A, LD704.A, LD705.A, LD706.A, LD707.A, LD708.A, LD709.A, LD710.A, LD711.A, LD712.A, LD713.A, LD714.A, LD715.A, LD716.A, LD717.A, LD718.A, LD719.A, LD720.A, LD721.A, LD722.A, LD723.A, LD724.A, LD725.A, LD726.A, R1091.2, R1096.2, R1101.2, R1106.2, R1111.2, R1116.2, R1121.2, R1126.2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; also elsewhere on the board
DOUT_U215: R1093.2; also elsewhere on the board
DOUT_U216: R1092.2, R1098.2; also elsewhere on the board
DOUT_U221: R1114.1, R1117.2, R1123.2
DOUT_U222: R1119.1, R1122.2, R1128.2
DOUT_U227: R1144.1, R1147.2, R1153.2
DOUT_U228: R1149.1, R1152.2, R1158.2
DOUT_U233: R1174.1, R1177.2, R1183.2
DOUT_U234: R1179.1, R1182.2, R1188.2
DOUT_U239: R1204.1, R1207.2; also elsewhere on the board
DOUT_U240: R1209.1; also elsewhere on the board
GND: C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, R1095.1, R1100.1, R1105.1, R1110.1, R1115.1, R1120.1, R1125.1, R1130.1, R1135.1, R1140.1, R1145.1, R1150.1, R1155.1, R1160.1, R1165.1, R1170.1, R1175.1, R1180.1, R1185.1, R1190.1, R1195.1, R1200.1, R1205.1, R1210.1, U217.5 (GND), U218.5 (GND), U219.5 (GND), U220.5 (GND), U221.5 (GND), U222.5 (GND), U223.5 (GND), U224.5 (GND), U225.5 (GND), U226.5 (GND), U227.5 (GND), U228.5 (GND), U229.5 (GND), U230.5 (GND), U231.5 (GND), U232.5 (GND), U233.5 (GND), U234.5 (GND), U235.5 (GND), U236.5 (GND), U237.5 (GND), U238.5 (GND), U239.5 (GND), U240.5 (GND); also elsewhere on the board
unnamed: C219.1, R1091.1, U217.9 (VDD)
unnamed: LD655.K (C), U217.1 (R)
unnamed: LD656.K (C), U217.2 (G)
unnamed: LD657.K (C), U217.3 (B)
unnamed: R1092.1, U217.8 (DIN)
unnamed: R1093.1, U217.6 (FDIN)
unnamed: R1094.2, U217.10 (DOUT)
unnamed: R1095.2, U217.7 (REXT)
unnamed: LD658.K (C), U218.1 (R)
unnamed: LD659.K (C), U218.2 (G)
unnamed: LD660.K (C), U218.3 (B)
unnamed: C220.1, R1096.1, U218.9 (VDD)
unnamed: R1097.1, U218.8 (DIN)
unnamed: R1098.1, U218.6 (FDIN)
unnamed: R1099.2, U218.10 (DOUT)
unnamed: R1100.2, U218.7 (REXT)
unnamed: R1099.1, R1102.2, R1108.2
unnamed: C221.1, R1101.1, U219.9 (VDD)
unnamed: LD661.K (C), U219.1 (R)
unnamed: LD662.K (C), U219.2 (G)
unnamed: LD663.K (C), U219.3 (B)
unnamed: R1102.1, U219.8 (DIN)
unnamed: R1103.1, U219.6 (FDIN)
unnamed: R1104.2, U219.10 (DOUT)
unnamed: R1105.2, U219.7 (REXT)
unnamed: LD664.K (C), U220.1 (R)
unnamed: LD665.K (C), U220.2 (G)
unnamed: LD666.K (C), U220.3 (B)
unnamed: C222.1, R1106.1, U220.9 (VDD)
unnamed: R1107.1, U220.8 (DIN)
unnamed: R1108.1, U220.6 (FDIN)
unnamed: R1094.1, R1097.2, R1103.2
unnamed: R1109.2, U220.10 (DOUT)
unnamed: R1110.2, U220.7 (REXT)
unnamed: R1109.1, R1112.2, R1118.2
unnamed: C223.1, R1111.1, U221.9 (VDD)
unnamed: LD667.K (C), U221.1 (R)
unnamed: LD668.K (C), U221.2 (G)
unnamed: LD669.K (C), U221.3 (B)
unnamed: R1112.1, U221.8 (DIN)
unnamed: R1113.1, U221.6 (FDIN)
unnamed: R1114.2, U221.10 (DOUT)
unnamed: R1115.2, U221.7 (REXT)
unnamed: LD670.K (C), U222.1 (R)
unnamed: LD671.K (C), U222.2 (G)
unnamed: LD672.K (C), U222.3 (B)
unnamed: C224.1, R1116.1, U222.9 (VDD)
unnamed: R1117.1, U222.8 (DIN)
unnamed: R1118.1, U222.6 (FDIN)
unnamed: R1104.1, R1107.2, R1113.2
unnamed: R1119.2, U222.10 (DOUT)
unnamed: R1120.2, U222.7 (REXT)
unnamed: C225.1, R1121.1, U223.9 (VDD)
unnamed: LD673.K (C), U223.1 (R)
unnamed: LD674.K (C), U223.2 (G)
unnamed: LD675.K (C), U223.3 (B)
unnamed: R1122.1, U223.8 (DIN)
unnamed: R1123.1, U223.6 (FDIN)
unnamed: R1124.2, U223.10 (DOUT)
unnamed: R1125.2, U223.7 (REXT)
unnamed: LD676.K (C), U224.1 (R)
unnamed: LD677.K (C), U224.2 (G)
unnamed: LD678.K (C), U224.3 (B)
unnamed: C226.1, R1126.1, U224.9 (VDD)
unnamed: R1127.1, U224.8 (DIN)
unnamed: R1128.1, U224.6 (FDIN)
unnamed: R1129.2, U224.10 (DOUT)
unnamed: R1130.2, U224.7 (REXT)
unnamed: R1129.1, R1132.2, R1138.2
unnamed: C227.1, R1131.1, U225.9 (VDD)
unnamed: LD679.K (C), U225.1 (R)
unnamed: LD680.K (C), U225.2 (G)
unnamed: LD681.K (C), U225.3 (B)
unnamed: R1132.1, U225.8 (DIN)
unnamed: R1133.1, U225.6 (FDIN)
unnamed: R1134.2, U225.10 (DOUT)
unnamed: R1135.2, U225.7 (REXT)
unnamed: LD682.K (C), U226.1 (R)
unnamed: LD683.K (C), U226.2 (G)
unnamed: LD684.K (C), U226.3 (B)
unnamed: C228.1, R1136.1, U226.9 (VDD)
unnamed: R1137.1, U226.8 (DIN)
unnamed: R1138.1, U226.6 (FDIN)
unnamed: R1124.1, R1127.2, R1133.2
unnamed: R1139.2, U226.10 (DOUT)
unnamed: R1140.2, U226.7 (REXT)
unnamed: R1139.1, R1142.2, R1148.2
unnamed: C229.1, R1141.1, U227.9 (VDD)
unnamed: LD685.K (C), U227.1 (R)
unnamed: LD686.K (C), U227.2 (G)
unnamed: LD687.K (C), U227.3 (B)
unnamed: R1142.1, U227.8 (DIN)
unnamed: R1143.1, U227.6 (FDIN)
unnamed: R1144.2, U227.10 (DOUT)
unnamed: R1145.2, U227.7 (REXT)
unnamed: LD688.K (C), U228.1 (R)
unnamed: LD689.K (C), U228.2 (G)
unnamed: LD690.K (C), U228.3 (B)
unnamed: C230.1, R1146.1, U228.9 (VDD)
unnamed: R1147.1, U228.8 (DIN)
unnamed: R1148.1, U228.6 (FDIN)
unnamed: R1134.1, R1137.2, R1143.2
unnamed: R1149.2, U228.10 (DOUT)
unnamed: R1150.2, U228.7 (REXT)
unnamed: C231.1, R1151.1, U229.9 (VDD)
unnamed: LD691.K (C), U229.1 (R)
unnamed: LD692.K (C), U229.2 (G)
unnamed: LD693.K (C), U229.3 (B)
unnamed: R1152.1, U229.8 (DIN)
unnamed: R1153.1, U229.6 (FDIN)
unnamed: R1154.2, U229.10 (DOUT)
unnamed: R1155.2, U229.7 (REXT)
unnamed: LD694.K (C), U230.1 (R)
unnamed: LD695.K (C), U230.2 (G)
unnamed: LD696.K (C), U230.3 (B)
unnamed: C232.1, R1156.1, U230.9 (VDD)
unnamed: R1157.1, U230.8 (DIN)
unnamed: R1158.1, U230.6 (FDIN)
unnamed: R1159.2, U230.10 (DOUT)
unnamed: R1160.2, U230.7 (REXT)
unnamed: R1159.1, R1162.2, R1168.2
unnamed: C233.1, R1161.1, U231.9 (VDD)
unnamed: LD697.K (C), U231.1 (R)
unnamed: LD698.K (C), U231.2 (G)
unnamed: LD699.K (C), U231.3 (B)
unnamed: R1162.1, U231.8 (DIN)
unnamed: R1163.1, U231.6 (FDIN)
unnamed: R1164.2, U231.10 (DOUT)
unnamed: R1165.2, U231.7 (REXT)
unnamed: LD700.K (C), U232.1 (R)
unnamed: LD701.K (C), U232.2 (G)
unnamed: LD702.K (C), U232.3 (B)
unnamed: C234.1, R1166.1, U232.9 (VDD)
unnamed: R1167.1, U232.8 (DIN)
unnamed: R1168.1, U232.6 (FDIN)
unnamed: R1154.1, R1157.2, R1163.2
unnamed: R1169.2, U232.10 (DOUT)
unnamed: R1170.2, U232.7 (REXT)
unnamed: R1169.1, R1172.2, R1178.2
unnamed: C235.1, R1171.1, U233.9 (VDD)
unnamed: LD703.K (C), U233.1 (R)
unnamed: LD704.K (C), U233.2 (G)
unnamed: LD705.K (C), U233.3 (B)
unnamed: R1172.1, U233.8 (DIN)
unnamed: R1173.1, U233.6 (FDIN)
unnamed: R1174.2, U233.10 (DOUT)
unnamed: R1175.2, U233.7 (REXT)
unnamed: LD706.K (C), U234.1 (R)
unnamed: LD707.K (C), U234.2 (G)
unnamed: LD708.K (C), U234.3 (B)
unnamed: C236.1, R1176.1, U234.9 (VDD)
unnamed: R1177.1, U234.8 (DIN)
unnamed: R1178.1, U234.6 (FDIN)
unnamed: R1164.1, R1167.2, R1173.2
unnamed: R1179.2, U234.10 (DOUT)
unnamed: R1180.2, U234.7 (REXT)
unnamed: C237.1, R1181.1, U235.9 (VDD)
unnamed: LD709.K (C), U235.1 (R)
unnamed: LD710.K (C), U235.2 (G)
unnamed: LD711.K (C), U235.3 (B)
unnamed: R1182.1, U235.8 (DIN)
unnamed: R1183.1, U235.6 (FDIN)
unnamed: R1184.2, U235.10 (DOUT)
unnamed: R1185.2, U235.7 (REXT)
unnamed: LD712.K (C), U236.1 (R)
unnamed: LD713.K (C), U236.2 (G)
unnamed: LD714.K (C), U236.3 (B)
unnamed: C238.1, R1186.1, U236.9 (VDD)
unnamed: R1187.1, U236.8 (DIN)
unnamed: R1188.1, U236.6 (FDIN)
unnamed: R1189.2, U236.10 (DOUT)
unnamed: R1190.2, U236.7 (REXT)
unnamed: R1189.1, R1192.2, R1198.2
unnamed: C239.1, R1191.1, U237.9 (VDD)
unnamed: LD715.K (C), U237.1 (R)
unnamed: LD716.K (C), U237.2 (G)
unnamed: LD717.K (C), U237.3 (B)
unnamed: R1192.1, U237.8 (DIN)
unnamed: R1193.1, U237.6 (FDIN)
unnamed: R1194.2, U237.10 (DOUT)
unnamed: R1195.2, U237.7 (REXT)
unnamed: LD718.K (C), U238.1 (R)
unnamed: LD719.K (C), U238.2 (G)
unnamed: LD720.K (C), U238.3 (B)
unnamed: C240.1, R1196.1, U238.9 (VDD)
unnamed: R1197.1, U238.8 (DIN)
unnamed: R1194.1, R1197.2, R1203.2
unnamed: R1198.1, U238.6 (FDIN)
unnamed: R1184.1, R1187.2, R1193.2
unnamed: R1199.2, U238.10 (DOUT)
unnamed: R1200.2, U238.7 (REXT)
unnamed: R1199.1, R1202.2, R1208.2
unnamed: C241.1, R1201.1, U239.9 (VDD)
unnamed: LD721.K (C), U239.1 (R)
unnamed: LD722.K (C), U239.2 (G)
unnamed: LD723.K (C), U239.3 (B)
unnamed: R1202.1, U239.8 (DIN)
unnamed: R1203.1, U239.6 (FDIN)
unnamed: R1204.2, U239.10 (DOUT)
unnamed: R1205.2, U239.7 (REXT)
unnamed: LD724.K (C), U240.1 (R)
unnamed: LD725.K (C), U240.2 (G)
unnamed: LD726.K (C), U240.3 (B)
unnamed: C242.1, R1206.1, U240.9 (VDD)
unnamed: R1207.1, U240.8 (DIN)
unnamed: R1208.1, U240.6 (FDIN)
unnamed: R1209.2, U240.10 (DOUT)
unnamed: R1210.2, U240.7 (REXT)

Schematic: RU-PCBA-2X2-001-03.sch, sheet 11, Row 11

Parts:
C243, C244, C245, C246, C247, C248, C249, C250, C251, C252, C253, C254, C255, C256, C257, C258, C259, C260, C261, C262, C263, C264, C265, C266: C-EUC1206; C1206; MPN C_104
LD727, LD733, LD739, LD745, LD751, LD757, LD763, LD769, LD775, LD781, LD787, LD793: R; 5050LED; MPN R_5050
LD728, LD734, LD740, LD746, LD752, LD758, LD764, LD770, LD776, LD782, LD788, LD794: G; 5050LED; MPN G_5050
LD729, LD735, LD741, LD747, LD753, LD759, LD765, LD771, LD777, LD783, LD789, LD795: B; 5050LED; MPN B_5050
LD730, LD736, LD742, LD748, LD754, LD760, LD766, LD772, LD778, LD784, LD790, LD796: A; 5050LED; MPN A_5050
LD731, LD737, LD743, LD749, LD755, LD761, LD767, LD773, LD779, LD785, LD791, LD797: C; 5050LED; MPN C_5050
LD732, LD738, LD744, LD750, LD756, LD762, LD768, LD774, LD780, LD786, LD792, LD798: L; 5050LED; MPN L_5050
R1211, R1216, R1221, R1226, R1231, R1236, R1241, R1246, R1251, R1256, R1261, R1266, R1271, R1276, R1281, R1286, R1291, R1296, R1301, R1306, R1311, R1316, R1321, R1326: 2k; R1206; MPN R_VDD
R1212, R1213, R1217, R1218, R1222, R1223, R1227, R1228, R1232, R1233, R1237, R1238, R1242, R1243, R1247, R1248, R1252, R1253, R1257, R1258, R1262, R1263, R1267, R1268, R1272, R1273, R1277, R1278, R1282, R1283, R1287, R1288, R1292, R1293, R1297, R1298, R1302, R1303, R1307, R1308, R1312, R1313, R1317, R1318, R1322, R1323, R1327, R1328: 500; R0805; MPN R_500
R1214, R1219, R1224, R1229, R1234, R1239, R1244, R1249, R1254, R1259, R1264, R1269, R1274, R1279, R1284, R1289, R1294, R1299, R1304, R1309, R1314, R1319, R1324, R1329: 120; R0805; MPN R_120
R1215, R1220, R1225, R1230, R1235, R1240, R1245, R1250, R1255, R1260, R1265, R1270, R1275, R1280, R1285, R1290, R1295, R1300, R1305, R1310, R1315, R1320, R1325, R1330: 4.3K; R0805; MPN R_EXT
U241, U242, U243, U244, U245, U246, U247, U248, U249, U250, U251, U252, U253, U254, U255, U256, U257, U258, U259, U260, U261, U262, U263, U264: UCS7604; SOP100P600X175-10N; MPN UCS7604

Connections:
+24V: LD727.A, LD728.A, LD729.A, LD730.A, LD731.A, LD732.A, LD733.A, LD734.A, LD735.A, LD736.A, LD737.A, LD738.A, LD739.A, LD740.A, LD741.A, LD742.A, LD743.A, LD744.A, LD745.A, LD746.A, LD747.A, LD748.A, LD749.A, LD750.A, LD751.A, LD752.A, LD753.A, LD754.A, LD755.A, LD756.A, LD757.A, LD758.A, LD759.A, LD760.A, LD761.A, LD762.A, LD763.A, LD764.A, LD765.A, LD766.A, LD767.A, LD768.A, LD769.A, LD770.A, LD771.A, LD772.A, LD773.A, LD774.A, LD775.A, LD776.A, LD777.A, LD778.A, LD779.A, LD780.A, LD781.A, LD782.A, LD783.A, LD784.A, LD785.A, LD786.A, LD787.A, LD788.A, LD789.A, LD790.A, LD791.A, LD792.A, LD793.A, LD794.A, LD795.A, LD796.A, LD797.A, LD798.A, R1211.2, R1216.2, R1221.2, R1226.2, R1231.2, R1236.2, R1241.2, R1246.2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; also elsewhere on the board
DOUT_U239: R1213.2; also elsewhere on the board
DOUT_U240: R1212.2, R1218.2; also elsewhere on the board
DOUT_U245: R1234.1, R1237.2, R1243.2
DOUT_U246: R1239.1, R1242.2, R1248.2
DOUT_U251: R1264.1, R1267.2, R1273.2
DOUT_U252: R1269.1, R1272.2, R1278.2
DOUT_U257: R1294.1, R1297.2, R1303.2
DOUT_U258: R1299.1, R1302.2, R1308.2
DOUT_U263: R1324.1, R1327.2; also elsewhere on the board
DOUT_U264: R1329.1; also elsewhere on the board
GND: C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, C263.2, C264.2, C265.2, C266.2, R1215.1, R1220.1, R1225.1, R1230.1, R1235.1, R1240.1, R1245.1, R1250.1, R1255.1, R1260.1, R1265.1, R1270.1, R1275.1, R1280.1, R1285.1, R1290.1, R1295.1, R1300.1, R1305.1, R1310.1, R1315.1, R1320.1, R1325.1, R1330.1, U241.5 (GND), U242.5 (GND), U243.5 (GND), U244.5 (GND), U245.5 (GND), U246.5 (GND), U247.5 (GND), U248.5 (GND), U249.5 (GND), U250.5 (GND), U251.5 (GND), U252.5 (GND), U253.5 (GND), U254.5 (GND), U255.5 (GND), U256.5 (GND), U257.5 (GND), U258.5 (GND), U259.5 (GND), U260.5 (GND), U261.5 (GND), U262.5 (GND), U263.5 (GND), U264.5 (GND); also elsewhere on the board
unnamed: C243.1, R1211.1, U241.9 (VDD)
unnamed: LD727.K (C), U241.1 (R)
unnamed: LD728.K (C), U241.2 (G)
unnamed: LD729.K (C), U241.3 (B)
unnamed: R1212.1, U241.8 (DIN)
unnamed: R1213.1, U241.6 (FDIN)
unnamed: R1214.2, U241.10 (DOUT)
unnamed: R1215.2, U241.7 (REXT)
unnamed: LD730.K (C), U242.1 (R)
unnamed: LD731.K (C), U242.2 (G)
unnamed: LD732.K (C), U242.3 (B)
unnamed: C244.1, R1216.1, U242.9 (VDD)
unnamed: R1217.1, U242.8 (DIN)
unnamed: R1218.1, U242.6 (FDIN)
unnamed: R1219.2, U242.10 (DOUT)
unnamed: R1220.2, U242.7 (REXT)
unnamed: R1219.1, R1222.2, R1228.2
unnamed: C245.1, R1221.1, U243.9 (VDD)
unnamed: LD733.K (C), U243.1 (R)
unnamed: LD734.K (C), U243.2 (G)
unnamed: LD735.K (C), U243.3 (B)
unnamed: R1222.1, U243.8 (DIN)
unnamed: R1223.1, U243.6 (FDIN)
unnamed: R1224.2, U243.10 (DOUT)
unnamed: R1225.2, U243.7 (REXT)
unnamed: LD736.K (C), U244.1 (R)
unnamed: LD737.K (C), U244.2 (G)
unnamed: LD738.K (C), U244.3 (B)
unnamed: C246.1, R1226.1, U244.9 (VDD)
unnamed: R1227.1, U244.8 (DIN)
unnamed: R1228.1, U244.6 (FDIN)
unnamed: R1214.1, R1217.2, R1223.2
unnamed: R1229.2, U244.10 (DOUT)
unnamed: R1230.2, U244.7 (REXT)
unnamed: R1229.1, R1232.2, R1238.2
unnamed: C247.1, R1231.1, U245.9 (VDD)
unnamed: LD739.K (C), U245.1 (R)
unnamed: LD740.K (C), U245.2 (G)
unnamed: LD741.K (C), U245.3 (B)
unnamed: R1232.1, U245.8 (DIN)
unnamed: R1233.1, U245.6 (FDIN)
unnamed: R1234.2, U245.10 (DOUT)
unnamed: R1235.2, U245.7 (REXT)
unnamed: LD742.K (C), U246.1 (R)
unnamed: LD743.K (C), U246.2 (G)
unnamed: LD744.K (C), U246.3 (B)
unnamed: C248.1, R1236.1, U246.9 (VDD)
unnamed: R1237.1, U246.8 (DIN)
unnamed: R1238.1, U246.6 (FDIN)
unnamed: R1224.1, R1227.2, R1233.2
unnamed: R1239.2, U246.10 (DOUT)
unnamed: R1240.2, U246.7 (REXT)
unnamed: C249.1, R1241.1, U247.9 (VDD)
unnamed: LD745.K (C), U247.1 (R)
unnamed: LD746.K (C), U247.2 (G)
unnamed: LD747.K (C), U247.3 (B)
unnamed: R1242.1, U247.8 (DIN)
unnamed: R1243.1, U247.6 (FDIN)
unnamed: R1244.2, U247.10 (DOUT)
unnamed: R1245.2, U247.7 (REXT)
unnamed: LD748.K (C), U248.1 (R)
unnamed: LD749.K (C), U248.2 (G)
unnamed: LD750.K (C), U248.3 (B)
unnamed: C250.1, R1246.1, U248.9 (VDD)
unnamed: R1247.1, U248.8 (DIN)
unnamed: R1248.1, U248.6 (FDIN)
unnamed: R1249.2, U248.10 (DOUT)
unnamed: R1250.2, U248.7 (REXT)
unnamed: R1249.1, R1252.2, R1258.2
unnamed: C251.1, R1251.1, U249.9 (VDD)
unnamed: LD751.K (C), U249.1 (R)
unnamed: LD752.K (C), U249.2 (G)
unnamed: LD753.K (C), U249.3 (B)
unnamed: R1252.1, U249.8 (DIN)
unnamed: R1253.1, U249.6 (FDIN)
unnamed: R1254.2, U249.10 (DOUT)
unnamed: R1255.2, U249.7 (REXT)
unnamed: LD754.K (C), U250.1 (R)
unnamed: LD755.K (C), U250.2 (G)
unnamed: LD756.K (C), U250.3 (B)
unnamed: C252.1, R1256.1, U250.9 (VDD)
unnamed: R1257.1, U250.8 (DIN)
unnamed: R1258.1, U250.6 (FDIN)
unnamed: R1244.1, R1247.2, R1253.2
unnamed: R1259.2, U250.10 (DOUT)
unnamed: R1260.2, U250.7 (REXT)
unnamed: R1259.1, R1262.2, R1268.2
unnamed: C253.1, R1261.1, U251.9 (VDD)
unnamed: LD757.K (C), U251.1 (R)
unnamed: LD758.K (C), U251.2 (G)
unnamed: LD759.K (C), U251.3 (B)
unnamed: R1262.1, U251.8 (DIN)
unnamed: R1263.1, U251.6 (FDIN)
unnamed: R1264.2, U251.10 (DOUT)
unnamed: R1265.2, U251.7 (REXT)
unnamed: LD760.K (C), U252.1 (R)
unnamed: LD761.K (C), U252.2 (G)
unnamed: LD762.K (C), U252.3 (B)
unnamed: C254.1, R1266.1, U252.9 (VDD)
unnamed: R1267.1, U252.8 (DIN)
unnamed: R1268.1, U252.6 (FDIN)
unnamed: R1254.1, R1257.2, R1263.2
unnamed: R1269.2, U252.10 (DOUT)
unnamed: R1270.2, U252.7 (REXT)
unnamed: C255.1, R1271.1, U253.9 (VDD)
unnamed: LD763.K (C), U253.1 (R)
unnamed: LD764.K (C), U253.2 (G)
unnamed: LD765.K (C), U253.3 (B)
unnamed: R1272.1, U253.8 (DIN)
unnamed: R1273.1, U253.6 (FDIN)
unnamed: R1274.2, U253.10 (DOUT)
unnamed: R1275.2, U253.7 (REXT)
unnamed: LD766.K (C), U254.1 (R)
unnamed: LD767.K (C), U254.2 (G)
unnamed: LD768.K (C), U254.3 (B)
unnamed: C256.1, R1276.1, U254.9 (VDD)
unnamed: R1277.1, U254.8 (DIN)
unnamed: R1278.1, U254.6 (FDIN)
unnamed: R1279.2, U254.10 (DOUT)
unnamed: R1280.2, U254.7 (REXT)
unnamed: R1279.1, R1282.2, R1288.2
unnamed: C257.1, R1281.1, U255.9 (VDD)
unnamed: LD769.K (C), U255.1 (R)
unnamed: LD770.K (C), U255.2 (G)
unnamed: LD771.K (C), U255.3 (B)
unnamed: R1282.1, U255.8 (DIN)
unnamed: R1283.1, U255.6 (FDIN)
unnamed: R1284.2, U255.10 (DOUT)
unnamed: R1285.2, U255.7 (REXT)
unnamed: LD772.K (C), U256.1 (R)
unnamed: LD773.K (C), U256.2 (G)
unnamed: LD774.K (C), U256.3 (B)
unnamed: C258.1, R1286.1, U256.9 (VDD)
unnamed: R1287.1, U256.8 (DIN)
unnamed: R1288.1, U256.6 (FDIN)
unnamed: R1274.1, R1277.2, R1283.2
unnamed: R1289.2, U256.10 (DOUT)
unnamed: R1290.2, U256.7 (REXT)
unnamed: R1289.1, R1292.2, R1298.2
unnamed: C259.1, R1291.1, U257.9 (VDD)
unnamed: LD775.K (C), U257.1 (R)
unnamed: LD776.K (C), U257.2 (G)
unnamed: LD777.K (C), U257.3 (B)
unnamed: R1292.1, U257.8 (DIN)
unnamed: R1293.1, U257.6 (FDIN)
unnamed: R1294.2, U257.10 (DOUT)
unnamed: R1295.2, U257.7 (REXT)
unnamed: LD778.K (C), U258.1 (R)
unnamed: LD779.K (C), U258.2 (G)
unnamed: LD780.K (C), U258.3 (B)
unnamed: C260.1, R1296.1, U258.9 (VDD)
unnamed: R1297.1, U258.8 (DIN)
unnamed: R1298.1, U258.6 (FDIN)
unnamed: R1284.1, R1287.2, R1293.2
unnamed: R1299.2, U258.10 (DOUT)
unnamed: R1300.2, U258.7 (REXT)
unnamed: C261.1, R1301.1, U259.9 (VDD)
unnamed: LD781.K (C), U259.1 (R)
unnamed: LD782.K (C), U259.2 (G)
unnamed: LD783.K (C), U259.3 (B)
unnamed: R1302.1, U259.8 (DIN)
unnamed: R1303.1, U259.6 (FDIN)
unnamed: R1304.2, U259.10 (DOUT)
unnamed: R1305.2, U259.7 (REXT)
unnamed: LD784.K (C), U260.1 (R)
unnamed: LD785.K (C), U260.2 (G)
unnamed: LD786.K (C), U260.3 (B)
unnamed: C262.1, R1306.1, U260.9 (VDD)
unnamed: R1307.1, U260.8 (DIN)
unnamed: R1308.1, U260.6 (FDIN)
unnamed: R1309.2, U260.10 (DOUT)
unnamed: R1310.2, U260.7 (REXT)
unnamed: R1309.1, R1312.2, R1318.2
unnamed: C263.1, R1311.1, U261.9 (VDD)
unnamed: LD787.K (C), U261.1 (R)
unnamed: LD788.K (C), U261.2 (G)
unnamed: LD789.K (C), U261.3 (B)
unnamed: R1312.1, U261.8 (DIN)
unnamed: R1313.1, U261.6 (FDIN)
unnamed: R1314.2, U261.10 (DOUT)
unnamed: R1315.2, U261.7 (REXT)
unnamed: LD790.K (C), U262.1 (R)
unnamed: LD791.K (C), U262.2 (G)
unnamed: LD792.K (C), U262.3 (B)
unnamed: C264.1, R1316.1, U262.9 (VDD)
unnamed: R1317.1, U262.8 (DIN)
unnamed: R1318.1, U262.6 (FDIN)
unnamed: R1304.1, R1307.2, R1313.2
unnamed: R1319.2, U262.10 (DOUT)
unnamed: R1320.2, U262.7 (REXT)
unnamed: R1319.1, R1322.2, R1328.2
unnamed: C265.1, R1321.1, U263.9 (VDD)
unnamed: LD793.K (C), U263.1 (R)
unnamed: LD794.K (C), U263.2 (G)
unnamed: LD795.K (C), U263.3 (B)
unnamed: R1322.1, U263.8 (DIN)
unnamed: R1323.1, U263.6 (FDIN)
unnamed: R1324.2, U263.10 (DOUT)
unnamed: R1325.2, U263.7 (REXT)
unnamed: LD796.K (C), U264.1 (R)
unnamed: LD797.K (C), U264.2 (G)
unnamed: LD798.K (C), U264.3 (B)
unnamed: C266.1, R1326.1, U264.9 (VDD)
unnamed: R1327.1, U264.8 (DIN)
unnamed: R1328.1, U264.6 (FDIN)
unnamed: R1314.1, R1317.2, R1323.2
unnamed: R1329.2, U264.10 (DOUT)
unnamed: R1330.2, U264.7 (REXT)
